# Keil uVision project embeddedProject.uvprojx, settings and files
target embeddedProject (6160000::V6.16::ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF)   CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: embeddedProject +hex
  BeforeMake: ..\freertosPort.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx,STM32_THREAD_SAFE_STRATEGY=4, MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ../Core/Inc;             ../Drivers/STM32F7xx_HAL_Driver/Inc;             ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;             ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;             ../Drivers/CMSIS/Include;             ../Middlewares/Third_Party/FreeRTOS/Source/include;             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;             ..\ARES;             ..\MotionDriver\driver\include;             ..\MotionDriver\mpl;             ..\MotionDriver\mllite;             ..\MotionDriver\eMPL-hal;             ..\MotionDriver\driver\eMPL
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xc0000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fmc.c i2c.c rng.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Application/User/ARES
    ../ARES/: fmc_driver.c chassis.c iic_mpu9250.c observer.c ahrs.c myiic.c feedback_task.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_sdram.c stm32f7xx_hal_rng.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/DMP
    ../MotionDriver/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MotionDriver/driver/stm32L/: log_stm32.c
    ../MotionDriver/eMPL-hal/: eMPL_outputs.c
    ../MotionDriver/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    $TC_ROOT$/../../Users/ZouYu/Documents/embeddedProject/MotionDriver/mpl/: libmpllib.lib
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
